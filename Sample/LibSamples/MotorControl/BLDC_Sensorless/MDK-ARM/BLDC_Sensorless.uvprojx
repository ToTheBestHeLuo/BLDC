# Keil uVision project BLDC_Sensorless.uvprojx, settings and files
target BLDC_Sensorless (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN0230B3TV MindMotion
  pack: MindMotion.MM32SPIN0230_DFP.0.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLDC_Sensorless +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\GPIO_LED_Toggle;..\..\..\..\..\Device\CMSIS\Core\Include;..\..\..\..\..\Device\MM32SPIN0230\HAL_Lib\inc;..\..\..\..\..\Device\MM32SPIN0230\Include;..\BLDC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ../: main.c mm32spin0230_it.c gpio_led_toggle.c platform.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32SPIN0230/HAL_Lib/src/: hal_adc.c hal_comp.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../../../../../Device/MM32SPIN0230/Source/: system_mm32spin0230.c
    ../../../../../Device/MM32SPIN0230/Source/KEIL_StartAsm/: startup_mm32spin0230_keil.s
  group mcUSER
    ../BLDC/mcConfig/: mcConfig.c mcCMD.c
  group mcSOURCE
    ../BLDC/mcSource/: mcControl.c mcGlobal.c mcTable.c mcSensorless.c
