# IAR project GPIO_LED_Toggle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN0230B3TV MindMotion MM32SPIN0230B3TV
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\Device\CMSIS\Core\Include; ..\..\..\..\..\Device\MM32SPIN0230\HAL_Lib\inc; ..\..\..\..\..\Device\MM32SPIN0230\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GPIO_LED_Toggle.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../: main.c mm32spin0230_it.c gpio_led_toggle.c platform.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32SPIN0230/HAL_Lib/src/: hal_adc.c hal_comp.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../../../../../Device/MM32SPIN0230/Source/IAR_StartAsm/: startup_mm32spin0230_iar.s
    ../../../../../Device/MM32SPIN0230/Source/: system_mm32spin0230.c
